# Keil uVision project infantry.uvprojx, settings and files
target Infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMISS;..\CMISS\DSP\include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER;..\FWLIB\inc;..\DEVICE\inc;..\HARDWARE\inc;..\USERLIB\inc;..\USERLIB\shell;..\TASK\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMISS
    ../CMISS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f427_437xx.s stm32f4xx_it.c system_stm32f4xx.c
  group CMISS\DSP
    ../CMISS/DSP/: arm_cortexM4lf_math.lib
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS\CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS\PORT
    ../FreeRTOS/include/: FreeRTOSConfig.h
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USER
    ../USER/: infantry.h main.c sys.c math2.c delay.c
  group DEVICE
    ../DEVICE/src/: can1.c can2.c timer2.c timer6.c usart1.c usart3.c usart6.c usart7.c usart8.c
  group HARDWARE
    ../HARDWARE/src/: led.c buzzer.c can1_motor.c can2_motor.c power_output.c remoter.c autoaim.c judge_system.c
  group USERLIB
    ../USERLIB/src/: pid.c motor.c listen.c client_ui.c crc_check.c
  group SHELL
    ../USERLIB/shell/: shell.c shellio.c user_commands.c
  group TASK
    ../TASK/src/: init_task.c start_task.c buzzer_task.c remoter_task.c wt61c_task.c cansend_task.c chassis_task.c gimbal_task.c shooter_task.c autoaim_task.c judge_task.c detect_task.c shell_task.c
  group README
    ../: README.md
